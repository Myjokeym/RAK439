# Keil uVision project RAK439_CubeMX.uvproj, settings and files
target RAK439_CubeMX (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RAK439_CubeMX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;                         ../Drivers/STM32F4xx_HAL_Driver/Inc;                         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                         ../Drivers/CMSIS/Include;                         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                         ..\RAKSDK\examples_os\tcp_udp\include;                         ..\RAKSDK\rw_lib;                         ..\RAKSDK\common\include;                         ..\RAKSDK\bsp
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c freertos.c spi.c gpio.c usart.c tim.c adc.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c list.c croutine.c event_groups.c queue.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group platform_stm32f4xx/bsp_os
    ../RAKSDK/bsp/: bsp.c
  group rw_lib
    ../RAKSDK/rw_lib/: rw_lib_platform_os.c rw_os.c rak_wifi_lib_os_ARM_CM4_V1.0.6.14.lib
  group common/include
    ../RAKSDK/common/include/: rw_error.h rw_lib.h rw_socket.h
  group examples_os/tcp_udp
    ../RAKSDK/examples_os/tcp_udp/src/: ap_sta.c tcp_udp.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
