<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>common</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_error.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_lib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_socket.h</name>
      </file>
    </group>
    <group>
      <name>mem</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\mem\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\mem\lib_mem.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>examples_nos</name>
    <group>
      <name>easy_wps</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\ap_sta.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\easy_wps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\easywps_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\rw_app.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\tcp_udp.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>middleware</name>
  </group>
  <group>
    <name>platform_stm32f4xx</name>
    <group>
      <name>bsp</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\iar\iarread.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\iar\iarwrite.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\iar\startup_stm32f411xe.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\stm32f4xx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\stm32f4xx_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\stm32f4xx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\bsp\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>libraries</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>rw_lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\rw_lib\EWARM\rak_wifi_lib_nos_ARM_CM4F.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\rw_lib_platform.c</name>
    </file>
  </group>
</project>


