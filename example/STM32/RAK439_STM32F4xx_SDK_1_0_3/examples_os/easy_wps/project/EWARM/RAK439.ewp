# IAR project RAK439.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ..\..\..\..\platform\ST\CMSIS\Include; ..\..\..\..\platform\ST\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\platform\bsp_os; ..\..\..\..\common\include; ..\..\..\..\common\mem; ..\..\include; ..\..\..\..\common; ..\..\..\..\middleware\FreeRTOS\Source\include; ..\..\..\..\middleware\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\middleware\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\common
  OBJCOPY.OOCOutputFile: RAK439.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\rw_lib\EWARM\rak_wifi_lib_os_ARM_CM4F.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group common/include
    ../../../../common/include/: rw_error.h rw_lib.h rw_socket.h
  group examples_os/easy_wps
    ../../src/: ap_sta.c easy_wps.c easywps_test.c tcp_udp.c
    ../../include/: rw_app.h
  group middleware/FreeRTOS
    ../../../../middleware/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group middleware/FreeRTOS/CMSIS_RTOS
    ../../../../middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group middleware/FreeRTOS/portable
    ../../../../middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../middleware/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group platform_stm32f4xx/bsp
    ../../../../platform/bsp_os/: bsp.c bsp.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    ../../../../platform/bsp_os/iar/: iarread.c iarwrite.c startup_stm32f411xe.s
  group platform_stm32f4xx/libraries
    ../../../../platform/ST/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group rw_lib
    ../../../../rw_lib/EWARM/: rak_wifi_lib_os_ARM_CM4F.a
    ../../../../platform/: rw_lib_platform_os.c
    ../../../../common/rw_os/: rw_os.c rw_os.h
