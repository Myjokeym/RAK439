# Keil uVision project RAK439.uvprojx, settings and files
target RAK439 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RAK439
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\..\..\..\platform\ST\CMSIS\Include;..\..\..\..\platform\ST\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\platform\ST\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\platform\bsp_os;..\..\..\..\common;..\..\..\..\common\include;..\..\..\..\common\rw_os;..\..\include;..\..\..\..\middleware\FreeRTOS\Source\include;..\..\..\..\middleware\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\middleware\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group common/include
    ../../../../common/include/: rw_error.h rw_lib.h rw_socket.h
  group examples_os/tcp_udp
    ../../src/: ap_sta.c tcp_udp.c tcpudp_test.c
    ../../include/: rw_app.h
  group middleware/FreeRTOS
    ../../../../middleware/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group middleware/FreeRTOS/CMSIS_RTOS
    ../../../../middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group middleware/FreeRTOS/portable
    ../../../../middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../middleware/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group platform_stm32f4xx/bsp_os
    ../../../../platform/bsp_os/: bsp.c bsp.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    ../../../../platform/bsp_os/arm/: startup_stm32f411xe.s
  group platform_stm32f4xx/libraries
    ../../../../platform/ST/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group rw_lib
    ../../../../rw_lib/MDK_ARM/: rak_wifi_os_ARM_CM4F.lib
    ../../../../platform/: rw_lib_platform_os.c
    ../../../../common/rw_os/: rw_os.c
