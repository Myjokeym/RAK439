# IAR project RAK439.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NANO100LE3BN Nuvoton NANO100LE3BN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\platform\nano100\libraries\CMSIS\Include; ..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Include; ..\..\..\..\platform\nano100\bsp; ..\..\..\..\platform\nano100\rw_os; ..\..\..\..\common\include; ..\..\..\..\common\mem; ..\..\include; ..\..\..\..\middleware\uCOSIII\os_config; ..\..\..\..\middleware\uCOSIII\uC-CPU; ..\..\..\..\middleware\uCOSIII\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\middleware\uCOSIII\uC-LIB; ..\..\..\..\middleware\uCOSIII\uCOS-III\Source; ..\..\..\..\middleware\uCOSIII\uCOS-III\Cfg\ARM-Cortex-M0; ..\..\..\..\middleware\uCOSIII\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RAK439.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\..\..\\platform\nano100\NANO1xx.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\rw_lib\EWARM\rak_wifi_lib_os_ARM_CM0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group common/include
    ../../../../common/include/: rw_error.h rw_lib.h rw_socket.h
  group common/mem
    ../../../../common/mem/: lib_mem.c lib_mem.h
  group examples_os/easy_wps
    ../../src/: ap_sta.c easy_wps.c easywps_test.c tcp_udp.c
    ../../include/: rw_app.h
  group middleware/uCOSIII/uC-CPU
    ../../../../middleware/uCOSIII/uC-CPU/ARM-Cortex-M0/IAR/: cpu_a.asm cpu_c.c
    ../../../../middleware/uCOSIII/uC-CPU/: cpu_core.c
  group middleware/uCOSIII/uCOS-III
    ../../../../middleware/uCOSIII/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../../../../middleware/uCOSIII/uCOS-III/Source/: ucos_iii.c
  group platform_nano100/bsp
    ../../../../platform/nano100/bsp/: bsp_os.c bsp_os.h iarread.c iarwrite.c
  group platform_nano100/libraries
    ../../../../platform/nano100/libraries/NANO1xx_Drivers/Source/: nano1xx_fmc.c nano1xx_gpio.c nano1xx_pdma.c nano1xx_spi.c nano1xx_sys.c nano1xx_timer.c nano1xx_uart.c
    ../../../../platform/nano100/startup/iar/: startup_nano1xx.s
    ../../../../platform/nano100/startup/: system_nano1xx.c system_nano1xx.h
  group platform_nano100/rw_os
    ../../../../platform/nano100/rw_os/: rw_os.c rw_os.h
  group rw_lib
    ../../../../rw_lib/EWARM/: rak_wifi_lib_os_ARM_CM0.a
    ../../../../platform/nano100/: rw_lib_platform_os.c
