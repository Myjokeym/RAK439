<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>common</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_error.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_lib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\include\rw_socket.h</name>
      </file>
    </group>
    <group>
      <name>mem</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\mem\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\common\mem\lib_mem.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>examples_nos</name>
    <group>
      <name>ap_sta</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\ap_sta.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\apsta_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\rw_app.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>middleware</name>
  </group>
  <group>
    <name>platform_nano100</name>
    <group>
      <name>bsp</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\bsp\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\bsp\bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\bsp\iarread.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\bsp\iarwrite.c</name>
      </file>
    </group>
    <group>
      <name>libraries</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_fmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_pdma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_sys.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Source\nano1xx_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Source\IAR\startup_nano1xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Source\system_nano1xx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>rw_lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\rw_lib\EWARM\rak_wifi_lib_nos_ARM_CM0.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\nano100\rw_lib_platform.c</name>
    </file>
  </group>
</project>


