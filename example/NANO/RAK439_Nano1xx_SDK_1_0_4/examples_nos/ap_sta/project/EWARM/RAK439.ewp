# IAR project RAK439.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\platform\nano100\libraries\CMSIS\Include; ..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Include; ..\..\..\..\platform\nano100\bsp; ..\..\..\..\common\include; ..\..\..\..\common\mem; ..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RAK439.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\..\..\\platform\nano100\NANO1xx.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\rw_lib\EWARM\rak_wifi_lib_nos_ARM_CM0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group common/include
    ../../../../common/include/: rw_error.h rw_lib.h rw_socket.h
  group common/mem
    ../../../../common/mem/: lib_mem.c lib_mem.h
  group examples_nos/ap_sta
    ../../src/: ap_sta.c apsta_test.c
    ../../include/: rw_app.h
  group platform_nano100/bsp
    ../../../../platform/nano100/bsp/: bsp.c bsp.h iarread.c iarwrite.c
  group platform_nano100/libraries
    ../../../../platform/nano100/libraries/NANO1xx_Drivers/Source/: nano1xx_fmc.c nano1xx_gpio.c nano1xx_pdma.c nano1xx_spi.c nano1xx_sys.c nano1xx_timer.c nano1xx_uart.c
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/: system_nano1xx.c
  group rw_lib
    ../../../../rw_lib/EWARM/: rak_wifi_lib_nos_ARM_CM0.a
    ../../../../platform/nano100/: rw_lib_platform.c
