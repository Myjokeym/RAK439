# Keil uVision project RAK439.uvproj, settings and files
target RAK439 (ARM-ADS)
  device: NANO100LE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: RAK439
  c flags: Optim=1
  c misc: --C99 --gnu
  c include: ..\..\..\..\platform\nano100\libraries\CMSIS\Include;..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Include;..\..\..\..\platform\nano100\bsp;..\..\..\..\common\include;..\..\..\..\common\mem;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group common/include
    ../../../../common/include/: rw_error.h rw_lib.h rw_socket.h
  group common/mem
    ../../../../common/mem/: lib_mem.c lib_mem.h
  group examples_nos/easy_wps
    ../../include/: rw_app.h
    ../../src/: ap_sta.c easy_wps.c tcp_udp.c easywps_test.c
  group platform_nano100/bsp
    ../../../../platform/nano100/bsp/: bsp.c bsp.h
  group platform_nano100/libraries
    ../../../../platform/nano100/libraries/NANO1xx_Drivers/Source/: nano1xx_fmc.c nano1xx_gpio.c nano1xx_pdma.c nano1xx_spi.c nano1xx_sys.c nano1xx_timer.c nano1xx_uart.c
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/: system_nano1xx.c
  group platform_nano100
    ../../../../platform/nano100/: rw_lib_platform.c
  group rw_lib
    ../../../../rw_lib/MDK_ARM/: rak_wifi_nos_ARM_CM0.lib
